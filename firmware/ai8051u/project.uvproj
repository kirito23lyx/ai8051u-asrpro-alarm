# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(40000000)
  output: project +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: a02_timer.c a03_uart.c a04_key.c a05_beep.c a06_oled.c a07_oled_font.c a08_clock.c a09_alarm_app.c a12_eeprom.c a10_main.c
